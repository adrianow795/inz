# Keil uVision project Accel_proj.uvprojx, settings and files
target Accel_proj (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476JGYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Accel_proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;                    ../Drivers/STM32L4xx_HAL_Driver/Inc;                    ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                    ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                    ../Drivers/CMSIS/Include;   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;   ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash.c stm32l4xx_ll_usb.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pcd.c
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c gpio.c stm32l4xx_it.c spi.c usbd_conf.c usbd_cdc_if.c usbd_desc.c usb_device.c
  group SensorTile
    ../Inc/: LSM303AGR.h LSM6DSM.h LSM6DSM_Driver.h LSM303AGR_Driver.h
    ../Src/: LSM6DSM_Driver.c LSM303AGR_Driver.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Algoritms
    ../Src/: String_Decoder.c ComplementaryFilter.c
    ../Inc/: String_Decoder.h ComplementaryFilter.h
software components: CMSIS:CORE 4.1.0
